Commit message: before change

File: configs/urdfs/xarm6_grip.urdf (robot description, URDF)
Before this commit: robot UF_ROBOT, 20 links, 19 joints
Joints:
- joint base_to_gripper_center: origin xyz=0 0 0.17 rpy=0 0 0 -> xyz=0 0 0.14 rpy=0 0 0
